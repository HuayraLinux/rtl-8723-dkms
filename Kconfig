## Kconfig
```kconfig
config RTL8723BE
	tristate "Realtek 8723BE PCI WiFi"
	depends on PCI
	---help---
	  Help message of RTL8723BE
```
